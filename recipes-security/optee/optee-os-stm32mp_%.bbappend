FILESEXTRAPATHS_prepend := "${THISDIR}/optee-os:"

SRC_URI	+= " \
	file://0001-ADD-ASIMOV-SUPPORT-IN-OPTEE.patch \
	"
