FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}}:"


SRC_URI += " \
	file://0001-ADD-ASIMOV-SUPPORT-IN-TF.patch   \
	"
