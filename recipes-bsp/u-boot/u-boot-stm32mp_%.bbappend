FILESEXTRAPATHS_prepend := "${THISDIR}/u-boot-stm32mp:"


SRC_URI += "  \
	file://0001-ADD-ASIMOV-BOARD-DEVICE-TREE.patch   \
	"


